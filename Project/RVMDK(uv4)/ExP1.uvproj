# Keil uVision project ExP1.uvproj, settings and files
target ExP1 (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ExP1 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\FWlib\inc;..\..\Libraries\FWlib\src;..\..\Libraries\CMSIS;..\..\User;..\..\User\HardwareDriver;..\..\User\DP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group PWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c
  group HardwareDriver
    ../../User/HardwareDriver/: CAN_Configure.c RCC_Configure.c GPIO_Configure.c USART_Configure.c TIM_Configure.c SPI_Configure.c WDG_Configure.c NVIC_Configure.c
  group MT
    ../../User/HardwareDriver/: MT_Configure.c
    ../../User/DP/: MTDAT_Demux.c CANDAT_Handle.c
  group ST
    ../../User/DP/: STDAT_Demux.c
  group Math
    ../../User/DP/: Nidhogg_Math.c
